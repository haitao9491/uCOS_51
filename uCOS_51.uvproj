# Keil uVision project uCOS_51.uvproj, settings and files
target uCOS_51 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: uCOS_51 +hex
  c flags: Optimize=8 SizeSpeed=1
  group MCS-51
    ./uCOS-II/MCS-51/: STARTUP.A51 OS_CPU_A.ASM OS_CPU_C.C
  group uCOS-II
    ./uCOS-II/Src/: uCOS_II.C
  group BSP
    ./BSP/: serial.c system.c
  group APP
    ./APP/: main.c
  group Note
    ./Note/: ReadMe.txt
